## Kconfig
```kconfig
#
#gpio device configuration
#
menuconfig RK3288_GPIO
	bool "support GPIO devices"
	default n
	---help---
	 Say Y here if you support rk3288_gpio
```
